# Keil uVision project Project.uvproj, settings and files
target SRAM (ARM-ADS)
  device: STM32F207ZG STMicroelectronics
  cpu: IRAM(0x20000000-0x2001FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(25000000) CPUTYPE("Cortex-M3")
  output: STM3220F_EVAL
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: USE_STM3220F_EVAL, STM32F2XX, USE_STDPERIPH_DRIVER, USE_USART2
  c include: ..\..\..\..\Libraries\CMSIS\CM3\CoreSupport;..\..\..\..\Libraries\CMSIS\CM3\DeviceSupport\ST\STM32F2xx;..\..\..\..\Libraries\STM32F2xx_StdPeriph_Driver\inc;..\..\..\..\Utilities\STM32_EVAL;..\..\..\..\Utilities\STM32_EVAL\Common;..\..\..\..\Utilities\STM32_EVAL\STM322xG_EVAL;..\..\..\..\Utilities\STM32_EVAL\FatFs_vR0.08a;..\..\BMP图像解码实验
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group User
    ../: main.c stm32f2xx_it.c
  group STM32_EVAL
    ../../../../Utilities/STM32_EVAL/: stm32_eval.c
    ../../../../Utilities/STM32_EVAL/STM322xG_EVAL/: stm322xg_eval_lcd.c stm322xg_eval_keypad.c stm322xg_eval_systick.c
    ../../../../Utilities/STM32_EVAL/Common/: ASC16.c fonts.c HzLib.c large_font.c
    ../: jpegdecode.c sys.c malloc.c gif.c
  group STM32F2xx_StdPeriph_Driver
    ../../../../Libraries/STM32F2xx_StdPeriph_Driver/src/: misc.c stm32f2xx_adc.c stm32f2xx_can.c stm32f2xx_crc.c stm32f2xx_cryp.c stm32f2xx_cryp_aes.c stm32f2xx_cryp_des.c stm32f2xx_cryp_tdes.c stm32f2xx_dac.c stm32f2xx_dbgmcu.c stm32f2xx_dcmi.c stm32f2xx_dma.c stm32f2xx_exti.c stm32f2xx_flash.c stm32f2xx_fsmc.c stm32f2xx_gpio.c stm32f2xx_hash.c stm32f2xx_hash_md5.c stm32f2xx_hash_sha1.c stm32f2xx_i2c.c stm32f2xx_iwdg.c stm32f2xx_pwr.c stm32f2xx_rcc.c stm32f2xx_rng.c stm32f2xx_rtc.c stm32f2xx_sdio.c stm32f2xx_spi.c stm32f2xx_syscfg.c stm32f2xx_tim.c stm32f2xx_usart.c stm32f2xx_wwdg.c
  group CMSIS
    ../: system_stm32f2xx.c
  group MDK-ARM
    ../../../../Libraries/CMSIS/CM3/DeviceSupport/ST/STM32F2xx/startup/arm/: startup_stm32f2xx.s
  group FAT
    ../../../../Utilities/STM32_EVAL/FatFs_vR0.08a/: ff.c diskio.c
    ../../../../Utilities/STM32_EVAL/FatFs_vR0.08a/option/: syscall.c
  group SD
    ../../../../Utilities/STM32_EVAL/STM322xG_EVAL/: stm32_eval_spi_sd.c
