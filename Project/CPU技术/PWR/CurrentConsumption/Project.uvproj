# Keil uVision project Project.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: STM32F207IG STMicroelectronics
  cpu: IRAM(0x20000000-0x2001FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(25000000) CPUTYPE("Cortex-M3")
  output: current
  c flags: Optim=1
  c define: USE_STM322xG_EVAL USE_FULL_ASSERT USE_STDPERIPH_DRIVER
  c include: ..\..\..\..\Libraries\CMSIS\CM3\DeviceSupport\ST\STM32F2xx;..\..\..\..\Libraries\STM32F2xx_StdPeriph_Driver\inc;..\..\..\..\Utilities\STM32_EVAL;..\..\..\..\Utilities\STM32_EVAL\STM322xG_EVAL;..\..\..\..\Utilities\STM32_EVAL\Common;..\CurrentConsumption
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group User
    ./: main.c stm32f2xx_it.c system_stm32f2xx.c stm32f2xx_lp_modes.c
  group stm32f2xx_stdperiph_driver
    ../../../../Libraries/STM32F2xx_StdPeriph_Driver/src/: misc.c stm32f2xx_dma.c stm32f2xx_exti.c stm32f2xx_fsmc.c stm32f2xx_gpio.c stm32f2xx_pwr.c stm32f2xx_rcc.c stm32f2xx_syscfg.c stm32f2xx_i2c.c stm32f2xx_sdio.c stm32f2xx_usart.c stm32f2xx_flash.c stm32f2xx_rtc.c stm32f2xx_adc.c stm32f2xx_can.c stm32f2xx_crc.c stm32f2xx_cryp.c stm32f2xx_cryp_aes.c stm32f2xx_cryp_des.c stm32f2xx_cryp_tdes.c stm32f2xx_dac.c stm32f2xx_dbgmcu.c stm32f2xx_dcmi.c stm32f2xx_hash.c stm32f2xx_hash_md5.c stm32f2xx_hash_sha1.c stm32f2xx_iwdg.c stm32f2xx_rng.c stm32f2xx_spi.c stm32f2xx_tim.c stm32f2xx_wwdg.c
  group cmsis
    ../../../../Libraries/CMSIS/CM3/CoreSupport/: core_cm3.c
  group mdk-arm
    ../../../../Libraries/CMSIS/CM3/DeviceSupport/ST/STM32F2xx/startup/arm/: startup_stm32f2xx.s
  group stm32_eval
    ../../../../Utilities/STM32_EVAL/STM322xG_EVAL/: stm322xg_eval.c stm322xg_eval_lcd.c
    ../../../../Utilities/STM32_EVAL/Common/: ASC16.c fonts.c HzLib.c large_font.c
